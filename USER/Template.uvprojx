# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\intconfig;..\HARDWARE;..\HARDWARE\timer;..\DEVICE;..\DEVICE\laser;..\APP;..\HARDWARE\usart3;..\DEVICE\paj7620u2;..\DEVICE\MPU6050\eMPL;..\DEVICE\MPU6050;..\HARDWARE\exti;..\HARDWARE\key;..\APP\distance;..\APP\move;..\DEVICE\encoder;..\DEVICE\motor;..\APP\control;..\HARDWARE\GPIO;..\DEVICE\valuepack
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c system_stm32f10x.c stm32f10x_it.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group APP
    ../APP/: app.h
    ../APP/distance/: distance.c distance.h
    ../APP/control/: control.c control.h
    ../APP/move/: move.c move.h
  group DEVICE
    ../DEVICE/: device.h
    ../DEVICE/laser/: laser.c laser.h
    ../DEVICE/paj7620u2/: paj7620u2.c paj7620u2.h paj7620u2_cfg.h paj7620u2_iic.c paj7620u2_iic.h
    ../DEVICE/MPU6050/: mpu6050.c mpu6050.h mpuiic.c mpuiic.h
    ../DEVICE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../DEVICE/encoder/: encoder.c encoder.h
    ../DEVICE/motor/: motor.c motor.h
    ../DEVICE/valuepack/: valuepack.c valuepack.h
  group HARDWARE
    ../HARDWARE/: hardware.h
    ../HARDWARE/intconfig/: intconfig.c intconfig.h
    ../HARDWARE/timer/: timer.c timer.h
    ../HARDWARE/usart3/: usart3.c usart3.h
    ../HARDWARE/GPIO/: gpio.c gpio.h
